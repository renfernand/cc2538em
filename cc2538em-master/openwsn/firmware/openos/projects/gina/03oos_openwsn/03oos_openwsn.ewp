# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\at86rf231\; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\gina\; ..\..\..\drivers\common\; ..\..\..\drivers\gina\; ..\..\..\openwsn\; ..\..\..\kernel\openos\; ..\..\..\openwsn\; ..\..\..\openwsn\02a-MAClow\; ..\..\..\openwsn\02b-MAChigh\; ..\..\..\openwsn\03a-IPHC\; ..\..\..\openwsn\03b-IPv6\; ..\..\..\openwsn\04-TRAN\; ..\..\..\openwsn\07-App\; ..\..\..\openwsn\07-App\heli\; ..\..\..\openwsn\07-App\imu\; ..\..\..\openwsn\07-App\layerdebug\; ..\..\..\openwsn\07-App\ohlone\; ..\..\..\openwsn\07-App\rex\; ..\..\..\openwsn\07-App\rheli\; ..\..\..\openwsn\07-App\rinfo\; ..\..\..\openwsn\07-App\rleds\; ..\..\..\openwsn\07-App\rreg\; ..\..\..\openwsn\07-App\rrube\; ..\..\..\openwsn\07-App\r6t\; ..\..\..\openwsn\07-App\rt\; ..\..\..\openwsn\07-App\rrt\; ..\..\..\openwsn\07-App\rwellknown\; ..\..\..\openwsn\07-App\rxl1\; ..\..\..\openwsn\07-App\tcpecho\; ..\..\..\openwsn\07-App\tcpinject\; ..\..\..\openwsn\07-App\tcpprint\; ..\..\..\openwsn\07-App\udpecho\; ..\..\..\openwsn\07-App\udpinject\; ..\..\..\openwsn\07-App\udplatency\; ..\..\..\openwsn\07-App\udpprint\; ..\..\..\openwsn\07-App\udprand\; ..\..\..\openwsn\07-App\udpstorm\; ..\..\..\openwsn\cross-layers\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h leds.h radio.h radiotimer.h uart.h
  group bsp/boards/gina
    ../../../bsp/boards/gina/: board.c board_info.h bsp_timer.c debugpins.c eui64.c i2c.c leds.c radiotimer.c spi.c uart.c
    ../../../drivers/gina/: gyro.c gyro.h large_range_accel.c large_range_accel.h magnetometer.c magnetometer.h sensitive_accel_temperature.c sensitive_accel_temperature.h
  group bsp/chips
    ../../../bsp/chips/: i2c.h spi.h
  group bsp/chips/at86rf231
    ../../../bsp/chips/at86rf231/: at86rf231.h radio.c
  group drivers/common
    ../../../drivers/common/: openhdlc.c openhdlc.h openserial.c openserial.h opentimers.c opentimers.h
  group drivers/gina
    ../../../drivers/gina/: ADC_Channel.c ADC_Channel.h
  group kernel
    ../../../kernel/openos/: scheduler.c scheduler.h
  group openwsn
    ../../../openwsn/: openwsn.c openwsn.h
  group openwsn/02a-MAClow
    ../../../openwsn/02a-MAClow/: adaptive_sync.c adaptive_sync.h IEEE802154.c IEEE802154.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openwsn/02b-MAChigh
    ../../../openwsn/02b-MAChigh/: neighbors.c neighbors.h res.c res.h schedule.c schedule.h
  group openwsn/03a-IPHC
    ../../../openwsn/03a-IPHC/: iphc.c iphc.h openbridge.c openbridge.h
  group openwsn/03b-IPv6
    ../../../openwsn/03b-IPv6/: forwarding.c forwarding.h icmpv6.c icmpv6.h icmpv6echo.c icmpv6echo.h icmpv6rpl.c icmpv6rpl.h
  group openwsn/04-TRAN
    ../../../openwsn/04-TRAN/: opencoap.c opencoap.h opentcp.c opentcp.h openudp.c openudp.h
  group openwsn/07-App/heli
    ../../../openwsn/07-App/heli/: heli.c heli.h
  group openwsn/07-App/imu
    ../../../openwsn/07-App/imu/: imu.c imu.h
  group openwsn/07-App/layerdebug
    ../../../openwsn/07-App/layerdebug/: layerdebug.c layerdebug.h
  group openwsn/07-App/ohlone
    ../../../openwsn/07-App/ohlone/: ohlone.c ohlone.h ohlone_webpages.c ohlone_webpages.h
  group openwsn/07-App/r6t
    ../../../openwsn/07-App/r6t/: r6t.c r6t.h
  group openwsn/07-App/rex
    ../../../openwsn/07-App/rex/: rex.c rex.h
  group openwsn/07-App/rheli
    ../../../openwsn/07-App/rheli/: rheli.c rheli.h
  group openwsn/07-App/rinfo
    ../../../openwsn/07-App/rinfo/: rinfo.c rinfo.h
  group openwsn/07-App/rleds
    ../../../openwsn/07-App/rleds/: rleds.c rleds.h
  group openwsn/07-App/rreg
    ../../../openwsn/07-App/rreg/: rreg.c rreg.h
  group openwsn/07-App/rrt
    ../../../openwsn/07-App/rrt/: rrt.c rrt.h
  group openwsn/07-App/rrube
    ../../../openwsn/07-App/rrube/: rrube.c rrube.h
  group openwsn/07-App/rt
    ../../../openwsn/07-App/rt/: rt.c rt.h
  group openwsn/07-App/rwellknown
    ../../../openwsn/07-App/rwellknown/: rwellknown.c rwellknown.h
  group openwsn/07-App/rxl1
    ../../../openwsn/07-App/rxl1/: rxl1.c rxl1.h
  group openwsn/07-App/tcpecho
    ../../../openwsn/07-App/tcpecho/: tcpecho.c tcpecho.h
  group openwsn/07-App/tcpinject
    ../../../openwsn/07-App/tcpinject/: tcpinject.c tcpinject.h
  group openwsn/07-App/tcpprint
    ../../../openwsn/07-App/tcpprint/: tcpprint.c tcpprint.h
  group openwsn/07-App/udpecho
    ../../../openwsn/07-App/udpecho/: udpecho.c udpecho.h
  group openwsn/07-App/udpinject
    ../../../openwsn/07-App/udpinject/: udpinject.c udpinject.h
  group openwsn/07-App/udplatency
    ../../../openwsn/07-App/udplatency/: udplatency.c udplatency.h
  group openwsn/07-App/udpprint
    ../../../openwsn/07-App/udpprint/: udpprint.c udpprint.h
  group openwsn/07-App/udprand
    ../../../openwsn/07-App/udprand/: udprand.c udprand.h
  group openwsn/07-App/udpstorm
    ../../../openwsn/07-App/udpstorm/: udpstorm.c udpstorm.h
  group openwsn/cross-layers
    ../../../openwsn/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
